# Keil uVision project loging.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: loging +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s mmc.c spi.c delay.c finalesd.c
    C:/Users/sanje/Downloads/ffsample (1)/lpc23xx/: ff.c ffsystem.c ffunicode.c diskio.c
